# Keil uVision project Project.uvprojx, settings and files
target STM32VL-Discovery (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32VL-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F100xB,USE_STM32VL_DISCO DEBUG
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32VL-Discovery;..\..\..\..\Drivers\Utils;..\..\..\..\Drivers\Middleware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group App
    ../Src/: main.c app_run.c app_init.c app_callbacks.c
    ../Inc/: app_globals.h
  group Middleware/modbus
    ../../../../Drivers/Middleware/: modbus_control.c modbus_protocol.c modbus_register.c
  group Debug
    ../../../../Drivers/Utils/: debug_print.c
  group Drivers/BSP
    ../../../../Drivers/BSP/STM32VL-Discovery/: stm32vl_discovery.c bsp_uart1.c bsp_spi1_dma.c bsp_tim3_ic.c bsp_tim1_pwm.c bsp_tim2_events.c bsp_dac.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_usart.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_adc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_crc.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Startup
    ./: startup_stm32f100xb.s
software components: CMSIS:CORE 4.1.0
